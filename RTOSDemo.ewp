# IAR project RTOSDemo.ewp, settings and files
configuration IAR_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ewarm; USE_CMSIS_REGISTER_FORMAT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\CMSIS\Include; $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM4F; driverlib; ..\Common\include; ..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; Full_Demo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __TM4L2001H8PZI__; ewarm
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\TexasInstruments
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\tm4l2001h8pzi.icf
  group (top)
    ./: FreeRTOSConfig.h main.c
  group DriverLibrary
    driverlib/: cpu.c cs.c flash.c fpu.c gpio.c interrupt.c pcm.c sysctl.c timer32.c uart.c wdt_a.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/include
    ../../Source/include/: event_groups.h FreeRTOS.h projdefs.h queue.h semphr.h task.h timers.h
  group FreeRTOS_Source/Portable/IAR/Cortex-M4F
    ../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group FreeRTOS_Source/Portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group Full_Demo
    Full_Demo/: IntQueueTimer.c main_full.c RegTest.s RunTimeStatsTimer.c serial.c
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group Full_Demo/FreeRTOS+CLI
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c FreeRTOS_CLI.h
  group Full_Demo/Standard Demo Tasks
    ../Common/Minimal/: BlockQ.c countsem.c EventGroupsDemo.c GenQTest.c IntQueue.c IntSemTest.c recmutex.c semtest.c sp_flop.c TaskNotify.c TimerDemo.c
  group Simply Blinky Demo
    SimplyBlinkyDemo/: main_blinky.c
  group System
    system/IAR/: msp432_startup_ewarm.c system_msp432p401r.c
